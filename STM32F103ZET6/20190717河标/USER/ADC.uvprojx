# Keil uVision project ADC.uvprojx, settings and files
target ADC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\POWER;..\HARDWARE\Filter;..\HARDWARE\GPS;..\HARDWARE\HC05;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/Filter/: Filter.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
